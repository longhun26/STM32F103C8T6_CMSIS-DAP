# Keil uVision project cmsis-dap.uvprojx, settings and files
target STM32F103-JLINK-OB-DAP (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: cmsis-dap +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER STM32F10X_MD JLINK_OB
  c include: .\CMSIS-DAP;.\USB;.\User;.\Driver\STM32F10x_ARM_Driver;.\Driver\STM32F10x_StdPeriph_Driver;.\Driver\STM32F10x_StdPeriph_Driver\inc;D:\Program Files\Keil_v5\ARM\RV31\INC;C:\Keil_v5\ARM\PACK\.Download\CMSIS\5.3.0\CMSIS\Include;C:\Keil_v5\ARM\PACK\.Download\CMSIS\5.3.0\CMSIS\Driver\Include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS-DAP
    ./CMSIS-DAP/: DAP.c JTAG_DP.c SW_DP.c SWO.c
  group Driver
    ./Driver/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_flash.c stm32f10x_rcc.c stm32f10x_gpio.c
  group USB
    ./USB/: usbd_STM32F103.c usbd_user_cdc_acm.c usbd_user_hid.c usb_config.c USB_CM3.lib
  group User
    ./User/: main.c system_stm32f10x.c startup_stm32f10x_md.s stm32f10x_conf.h
  group USART
    ./Driver/STM32F10x_ARM_Driver/: DMA_STM32F10x.c GPIO_STM32F10x.c USART_STM32F10x.c
target STM32F103-BOARD_V1 (5060960::V5.06 update 7 (build 960)::.\ARMC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: as above
  output: cmsis-dap
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER STM32F10X_MD BOARD_V1
  c include: .\CMSIS-DAP;.\USB;.\User;.\Driver\STM32F10x_ARM_Driver;.\Driver\STM32F10x_StdPeriph_Driver;.\Driver\STM32F10x_StdPeriph_Driver\inc;D:\Program Files\Keil_v5\ARM\RV31\INC;D:\Software\Arm\Packs\ARM\CMSIS\5.3.0\CMSIS\Include;D:\Software\Arm\Packs\ARM\CMSIS\5.3.0\CMSIS\Driver\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
target STM32F103-BOARD_V2 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: as above
  output: cmsis-dap
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER STM32F10X_MD BOARD_V2
  c include: .\CMSIS-DAP;.\USB;.\User;.\Driver\STM32F10x_ARM_Driver;.\Driver\STM32F10x_StdPeriph_Driver;.\Driver\STM32F10x_StdPeriph_Driver\inc;D:\Program Files\Keil_v5\ARM\RV31\INC;C:\Keil_v5\ARM\PACK\.Download\CMSIS\5.3.0\CMSIS\Driver\Include;C:\Keil_v5\ARM\PACK\.Download\CMSIS\5.3.0\CMSIS\Include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
target STM32F103-STLINK_V20 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: as above
  output: cmsis-dap
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER STM32F10X_MD STLINK_V20
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
target STM32F103-STLINK_V21 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: as above
  output: cmsis-dap
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER STM32F10X_MD STLINK_V21
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
target STM32F103-RF (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: as above
  output: cmsis-dap
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER STM32F10X_MD BOARD_STM32RF
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
target STM32F103-STLINK_V2A (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: as above
  output: cmsis-dap
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER STM32F10X_MD STLINK_V2A
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
target STM32F103-STLINK_V2B (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: as above
  output: cmsis-dap
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER STM32F10X_MD STLINK_V2B
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
