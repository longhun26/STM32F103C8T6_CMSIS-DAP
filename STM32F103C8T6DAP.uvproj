# Keil uVision project STM32F103C8T6DAP.uvproj, settings and files
target STM32F103-JLINK-OB-DAP (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: F103-DAP-SWO-CDC-BLUEPILL-SWD_PB8PB9 +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER STM32F10X_MD JLINK_OB
  c include: .\CMSIS-DAP;.\USB;.\User;.\Driver\STM32F10x_ARM_Driver;.\Driver\STM32F10x_StdPeriph_Driver\inc;D:\Program Files\Keil_v5\ARM\Pack\ARM\CMSIS\5.3.0\CMSIS\Include;D:\Program Files\Keil_v5\ARM\Pack\ARM\CMSIS\5.3.0\CMSIS\Driver\Include;D:\Program Files\Keil_v5\UV4\ARM\RV31\INC
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ./User/: main.c stm32f10x_conf.h system_stm32f10x.c startup_stm32f10x_md.s
  group CMSIS-DAP
    ./CMSIS-DAP/: DAP_config.h DAP.h DAP.c JTAG_DP.c SW_DP.c SWO.c
  group Driver
    ./Driver/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c
  group USART
    ./Driver/STM32F10x_ARM_Driver/: DMA_STM32F10x.c GPIO_STM32F10x.c USART_STM32F10x.c
  group USB
    ./USB/: usb_config.c usbd_STM32F103.c usbd_user_hid.c usbd_user_cdc_acm.c
    $TC_ROOT$/../UV4/ARM/RV31/LIB/: USB_CM3.lib
target STM32F103-BOARD_V1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  cpu: as above
  output: F103-DAP-SWO-CDC-BOARD_V1 +hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: USE_STDPERIPH_DRIVER STM32F10X_MD BOARD_V1 SWO_PA10
  c include: .\CMSIS-DAP;.\USB;.\User;.\Driver\STM32F10x_ARM_Driver;.\Driver\STM32F10x_StdPeriph_Driver\inc;C:\Keil\ARM\PACK\ARM\CMSIS\5.3.0\CMSIS\Include;C:\Keil\ARM\PACK\ARM\CMSIS\5.3.0\CMSIS\Driver\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
target STM32F102-BOARD_V2 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F102C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x200027FF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: F102-DAP-SWO-CDC-BOARD_V2 +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1
  c define: USE_STDPERIPH_DRIVER STM32F10X_MD BOARD_V2 STM32F102C8 SWO_PA10
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2800
target STM32F103-BOARD_V2 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  cpu: as above
  output: F103-DAP-SWO-CDC-BOARD_V2 +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1
  c define: USE_STDPERIPH_DRIVER STM32F10X_MD BOARD_V2 SWO_PA10
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
target STM32F103-STLINK_V20 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  cpu: as above
  output: F103-DAP-SWO-CDC-STLINK_V20-SWO_PA10 +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1
  c define: USE_STDPERIPH_DRIVER STM32F10X_MD STLINK_V20 SWO_PA10
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
target STM32F103-STLINK_V21 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  cpu: as above
  output: F103-DAP-SWO-CDC-STLINK_V21-SWO_PA10 +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1
  c define: USE_STDPERIPH_DRIVER STM32F10X_MD STLINK_V21 SWO_PA10
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
target STM32RF (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  cpu: as above
  output: F103-DAP-SWO-CDC-BOARD_RF +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: USE_STDPERIPH_DRIVER STM32F10X_MD BOARD_STM32RF SWO_PA10
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
target STM32F103-STLINK_V2A (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103CB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: F103-DAP-SWO-CDC-STLINK_V2A-SWO_PA10 +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1
  c define: USE_STDPERIPH_DRIVER STM32F10X_MD STLINK_V2A SWO_PA10
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target STM32F103-STLINK_V2B (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103CB STMicroelectronics
  cpu: as above
  output: F103-DAP-SWO-CDC-STLINK_V2B-SWO_PA10 +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1
  c define: USE_STDPERIPH_DRIVER STM32F10X_MD STLINK_V2B SWO_PA10
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
